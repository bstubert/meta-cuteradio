# Enable alsa and gstreamer
PACKAGECONFIG = "alsa gstreamer"

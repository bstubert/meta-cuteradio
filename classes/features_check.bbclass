# Adapt to old class name
inherit distro_features_check
